options:
  parameters:
    author: Camila Vinza
    generate_options: qt_gui
    id: FM
    output_language: python
    title: FM
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: cutoff_fre
  id: variable
  parameters:
    value: 8e3
  states: {}
- name: f
  id: variable
  parameters:
    value: int(89e6)
  states: {}
- name: frecuencia
  id: variable_qtgui_range
  parameters:
    label: Freq Transmision
    start: f
    step: int(100e3)
    stop: int(108e6)
    value: f
  states: {}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    label: Gain RX
    start: '1'
    step: '1'
    stop: '100'
    value: '45'
  states: {}
- name: gaintx
  id: variable_qtgui_range
  parameters:
    label: Gain TX
    start: '1'
    step: '1'
    stop: '100'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*4
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: Volumen RX
    start: '1'
    step: '1'
    stop: '20'
    value: '5'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: audio_music
  id: blocks_wavfile_source
  parameters:
    file: /home/robert/Music/first-love-letra-lyric.wav
    repeat: 'True'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: constx
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: audio_rate*10
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_fre
    gain: '0.8'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_fre
    decim: '10'
    gain: '1'
    samp_rate: audio_rate*10
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frecuencia
    fftsize: '1024'
    gui_hint: 1,0,1,2
    name: '"ESPECTO FM"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    name: '"Modulación FM"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: frecuencia
    dev_addr: '"serial=30875AE"'
    gain0: gaintx
    samp_rate: audio_rate*10
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 200e3
    center_freq0: frecuencia
    dev_addr: '"serial=30875AE"'
    gain0: gainrx
    samp_rate: audio_rate*10
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', low_pass_filter_2, '0']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_nbfm_rx_0, '0', analog_fm_deemph_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_tx_0, '0', qtgui_time_sink_x_0, '0']
- [audio_music, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [constx, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', analog_fm_preemph_0, '0']
- [low_pass_filter_2, '0', constx, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
