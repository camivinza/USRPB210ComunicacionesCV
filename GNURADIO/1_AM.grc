options:
  parameters:
    author: Camila Vinza
    generate_options: qt_gui
    id: AM
    output_language: python
    title: AM
  states: {}

blocks:
- name: cutoff_freq_filter
  id: variable
  parameters:
    value: int(10e3)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(44100)
  states: {}
- name: f
  id: variable
  parameters:
    value: int(900e6)
  states: {}
- name: fbase
  id: variable
  parameters:
    value: f/1e5
  states: {}
- name: frecuencia
  id: variable_qtgui_range
  parameters:
    label: Freq Transmision
    start: f
    step: int(100e3)
    stop: int(905e6)
    value: f
  states: {}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    label: Gain RX
    start: '1'
    step: '1'
    stop: '100'
    value: '35'
  states: {}
- name: gaintx
  id: variable_qtgui_range
  parameters:
    label: Gain TX
    start: '1'
    step: '1'
    stop: '100'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(96e3)
  states: {}
- name: volrx
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '1'
    step: '1'
    stop: '15'
    value: '1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-6'
    gain: '0'
    max_gain: '0'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: int(samp_rate/2)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fbase
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volrx
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/robert/Music/first-love-letra-lyric.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq_filter
    decim: '1'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq_filter
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frecuencia
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: '"ESPECTRO AM ENVIADO"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frecuencia
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: '"ESPECTO AM RECIBIDO"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    name: '"Modulación AM"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: int(samp_rate/2)
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frecuencia
    dev_addr: '"serial=30875AE"'
    gain0: gaintx
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frecuencia
    dev_addr: '"serial=30875AE"'
    gain0: gainrx
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_const_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_2, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '1']
- [low_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
