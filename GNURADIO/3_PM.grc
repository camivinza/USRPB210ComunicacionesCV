options:
  parameters:
    author: Camila Vinza
    generate_options: qt_gui
    id: PM
    output_language: python
    title: PM
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: cutoff_fre
  id: variable
  parameters:
    value: 15e3
  states: {}
- name: f
  id: variable
  parameters:
    value: int(89e6)
  states: {}
- name: frecuencia
  id: variable_qtgui_range
  parameters:
    label: Freq Transmision
    start: f
    step: int(100e3)
    stop: int(108e6)
    value: f
  states: {}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    label: Gain RX
    start: '1'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: gaintx
  id: variable_qtgui_range
  parameters:
    label: Gain TX
    start: '1'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sensivity
  id: variable_qtgui_range
  parameters:
    label: Sensibilidad
    start: '1'
    step: '1'
    stop: '100'
    value: '15'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '10000'
    audio_stop: '16000'
    chan_rate: audio_rate
    deviation: '75000'
    gain: '2'
    tau: '75e-6'
  states: {}
- name: audio_music
  id: blocks_wavfile_source
  parameters:
    file: /home/robert/Music/first-love-letra-lyric.wav
    repeat: 'True'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '4'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_fre
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_fre
    gain: '3'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: phase_mod
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: sensivity
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: frecuencia
    fftsize: '1024'
    gui_hint: 1,0,1,2
    name: '"Espectro PM"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    name: '"Modulación PM"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: audio_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: frecuencia
    dev_addr: '"serial=30875AE"'
    gain0: gaintx
    samp_rate: audio_rate*4
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 200e3
    center_freq0: frecuencia
    dev_addr: '"serial=30875AE"'
    gain0: gainrx
    samp_rate: audio_rate*4
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_fm_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [audio_music, '0', rational_resampler_xxx_1, '0']
- [blocks_integrate_xx_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_integrate_xx_0, '0']
- [low_pass_filter_1, '0', blocks_throttle2_0, '0']
- [phase_mod, '0', qtgui_time_sink_x_0, '0']
- [phase_mod, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', phase_mod, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_1, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
